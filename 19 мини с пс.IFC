Properties of the parts of a building model (IFC4), part 2 of 2

# IfcBuildingElementProxy: 19 мини.stp[399]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[39]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[3]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[400]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[401]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[402]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[403]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[404]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[405]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[406]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[407]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[408]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[409]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[40]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[410]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[411]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[412]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[413]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[414]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[415]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[416]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[417]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[418]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[419]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[41]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[420]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[421]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[422]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[423]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[424]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[425]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[426]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[427]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[428]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[429]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[42]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[430]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[431]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[432]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[433]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[434]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[435]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[436]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[437]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[438]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[439]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[43]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[440]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[441]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[442]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[443]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[444]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[445]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[446]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[447]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[448]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[449]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[44]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[450]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[451]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[452]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[453]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[454]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[455]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[456]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[457]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[458]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[459]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[45]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[460]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[461]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[462]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[463]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[464]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[465]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[466]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[467]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[468]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[469]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[46]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[470]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[471]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[472]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[473]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[474]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[475]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[476]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[477]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[478]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[479]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[47]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[480]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[481]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[482]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[483]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[484]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[485]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[486]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[487]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[488]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[489]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[48]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[490]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[491]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[492]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[493]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[494]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[495]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[496]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[497]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[498]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[499]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[49]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[4]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[500]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[501]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[502]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[503]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[504]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[505]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[506]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[507]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[508]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[509]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[50]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[510]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[511]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[512]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[513]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[514]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[515]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[516]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[517]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[518]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[519]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[51]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[520]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[521]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[522]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[523]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[524]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[525]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[526]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[527]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[528]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[529]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[52]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[530]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[531]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[532]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[533]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[534]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[535]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[536]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[537]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[538]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[539]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[53]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[540]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[541]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[542]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[543]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[544]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[545]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[546]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[547]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[548]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[549]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[54]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[550]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[551]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[552]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[553]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[554]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[555]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[556]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[557]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[558]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[559]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[55]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[560]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[561]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[562]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[563]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[564]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[565]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[566]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[567]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[568]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[569]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[56]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[570]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[571]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[572]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[573]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[574]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[575]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[576]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[577]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[578]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[579]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[57]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[580]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[581]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[582]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[583]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[584]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[585]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[586]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[587]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[588]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[589]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[58]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[590]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[591]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[592]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[593]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[594]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[595]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[596]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[597]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[598]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[599]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[59]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[5]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[600]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[601]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[602]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[603]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[604]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[605]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[606]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[607]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[608]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[609]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[60]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[610]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[611]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[612]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[613]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[614]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[615]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[616]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[617]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[618]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[619]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[61]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[620]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[621]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[622]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[623]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[624]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[625]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[626]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[627]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[628]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[629]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[62]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[630]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[631]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[632]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[633]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[634]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[635]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[636]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[637]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[638]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[639]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[63]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[640]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[641]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[642]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[643]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[644]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[645]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[646]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[647]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[648]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[649]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[64]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[650]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[651]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[652]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[653]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[654]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[655]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[656]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[657]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[658]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[659]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[65]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[660]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[661]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[662]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[663]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[664]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[665]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[666]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[667]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[668]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[669]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[66]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[670]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[671]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[672]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[673]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[674]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[675]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[676]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[677]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[678]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[679]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[67]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[680]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[681]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[682]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[683]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[684]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[685]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[686]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[687]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[688]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[689]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[68]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[690]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[691]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[692]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[693]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[694]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[695]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[696]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[697]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[698]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[699]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[69]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[6]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[700]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[701]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[702]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[703]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[704]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[705]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[706]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[707]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[708]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[709]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[70]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[710]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[711]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[712]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[713]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[714]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[715]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[716]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[717]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[718]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[719]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[71]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[720]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[721]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[722]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[723]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[724]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[725]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[726]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[727]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[728]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[729]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[72]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[730]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[731]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[732]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[733]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[734]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[735]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[736]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[737]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[738]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[739]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[73]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[740]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[741]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[742]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[743]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[744]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[745]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[746]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[747]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[748]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[749]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[74]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[750]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[751]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[752]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[753]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[754]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[755]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[756]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[757]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[758]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[759]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[75]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[760]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[761]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[762]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[763]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[764]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[765]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[766]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[767]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[768]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[769]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[76]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[770]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[771]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[772]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[773]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[774]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[775]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[776]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[777]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[778]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[779]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[77]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[780]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[781]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[782]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[783]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[784]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[785]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[786]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[787]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[788]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[789]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[78]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[790]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[791]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[792]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[793]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[794]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[795]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[796]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[797]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[798]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[799]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[79]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[7]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[800]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[801]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[802]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[803]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[804]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[805]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[806]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[807]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[808]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[809]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[80]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[810]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[811]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[812]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[813]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[814]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[815]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[816]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[817]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[818]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[819]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[81]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[820]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[821]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[822]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[823]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[824]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[825]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[826]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[827]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[828]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[829]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[82]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[830]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[831]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[832]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[833]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[834]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[835]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[836]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[837]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[838]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[839]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[83]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[840]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[841]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[842]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[843]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[844]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[845]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[846]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[847]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[848]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[849]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[84]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[850]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[851]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[852]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[853]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[854]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[855]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[856]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[857]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[858]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[859]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[85]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[860]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[861]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[862]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[863]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[864]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[865]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[866]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[867]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[868]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[869]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[86]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[870]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[871]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[872]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[873]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[874]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[875]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[876]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[877]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[878]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[879]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[87]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[880]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[881]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[882]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[883]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[884]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[885]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[886]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[887]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[888]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[889]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[88]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[890]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[891]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[892]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[893]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[894]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[895]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[896]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[897]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[898]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[899]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[89]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[8]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[900]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[901]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[902]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[903]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[904]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[905]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[906]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[907]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[908]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[909]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[90]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[910]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[911]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[912]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[913]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[914]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[915]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[916]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[917]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[918]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[919]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[91]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[920]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[921]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[922]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[923]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[924]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[925]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[926]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[927]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[928]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[929]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[92]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[930]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[931]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[932]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[933]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[934]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[935]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[936]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[937]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[938]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[939]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[93]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[940]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[941]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[942]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[943]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[944]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[945]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[946]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[947]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[948]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[949]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[94]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[950]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[951]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[952]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[953]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[954]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[955]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[956]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[957]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[958]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[959]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[95]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[960]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[961]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[962]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[963]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[964]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[965]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[966]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[967]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[968]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[969]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[96]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[970]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[971]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[972]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[973]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[974]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[975]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[976]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[977]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[978]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[979]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[97]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[980]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[981]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[982]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[983]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[984]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[985]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[986]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[987]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[988]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[989]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[98]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[990]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[991]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[992]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[993]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[994]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[995]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[996]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[997]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[998]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[999]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[99]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[9]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: SS.SEMA.2400 - Сима-профиль (66)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: SS.SEMA.2400 - Сима-профиль — обрезан 1600 (22)
In: Default Storey
PredefinedType: ELEMENT; Material: 0
