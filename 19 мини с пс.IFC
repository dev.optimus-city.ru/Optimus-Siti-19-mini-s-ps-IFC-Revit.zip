Properties of the parts of a building model (IFC4), part 1 of 2

# File
Description: IFC4
File name: 19 мини с пс.IFC
Time: 2025-11-26T04:43:24
Written by: SwIFC
Made in: SolidWorks 2020

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: 19 мини.stp[1000]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1001]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1002]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1003]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1004]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1005]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1006]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1007]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1008]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1009]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[100]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1010]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1011]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1012]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1013]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1014]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1015]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1016]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1017]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1018]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1019]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[101]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1020]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1021]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1022]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1023]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1024]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1025]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1026]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1027]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1028]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1029]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[102]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1030]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1031]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1032]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1033]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1034]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1035]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1036]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1037]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1038]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1039]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[103]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1040]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1041]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1042]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1043]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1044]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1045]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1046]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1047]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1048]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1049]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[104]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1050]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1051]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1052]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1053]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1054]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1055]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1056]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1057]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1058]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1059]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[105]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1060]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1061]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1062]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1063]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1064]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1065]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1066]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1067]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1068]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1069]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[106]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1070]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1071]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1072]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1073]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1074]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1075]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1076]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1077]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1078]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1079]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[107]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1080]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1081]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1082]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1083]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1084]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1085]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1086]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1087]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1088]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1089]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[108]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1090]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1091]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1092]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1093]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1094]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1095]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1096]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1097]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1098]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1099]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[109]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[10]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1100]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1101]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1102]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1103]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1104]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1105]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1106]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1107]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1108]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1109]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[110]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1110]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1111]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1112]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1113]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1114]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1115]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1116]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1117]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1118]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1119]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[111]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1120]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1121]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1122]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1123]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1124]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1125]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1126]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1127]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1128]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1129]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[112]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1130]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1131]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1132]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1133]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1134]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1135]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1136]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1137]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1138]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1139]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[113]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1140]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1141]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1142]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1143]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1144]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1145]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1146]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1147]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1148]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1149]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[114]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1150]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1151]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1152]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1153]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1154]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1155]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1156]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1157]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1158]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1159]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[115]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1160]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1161]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1162]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1163]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1164]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1165]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1166]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1167]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1168]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1169]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[116]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1170]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1171]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1172]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1173]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1174]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1175]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1176]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1177]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1178]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1179]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[117]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1180]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1181]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1182]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1183]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1184]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1185]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1186]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1187]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1188]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1189]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[118]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1190]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1191]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1192]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1193]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1194]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1195]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1196]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1197]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1198]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1199]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[119]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[11]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1200]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1201]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1202]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1203]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1204]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1205]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1206]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1207]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1208]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1209]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[120]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1210]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1211]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1212]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1213]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1214]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1215]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1216]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1217]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1218]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1219]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[121]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1220]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1221]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1222]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1223]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1224]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1225]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1226]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1227]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1228]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1229]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[122]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1230]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1231]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1232]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1233]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1234]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1235]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1236]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1237]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1238]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1239]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[123]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1240]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1241]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1242]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1243]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1244]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1245]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1246]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1247]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1248]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1249]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[124]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1250]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1251]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1252]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1253]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1254]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1255]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1256]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1257]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1258]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1259]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[125]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1260]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1261]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1262]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1263]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1264]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1265]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1266]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1267]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1268]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1269]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[126]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1270]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1271]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1272]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1273]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1274]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1275]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1276]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1277]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1278]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1279]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[127]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1280]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1281]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1282]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1283]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1284]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1285]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1286]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1287]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1288]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1289]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[128]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1290]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1291]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1292]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1293]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1294]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1295]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1296]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1297]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1298]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1299]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[129]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[12]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1300]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1301]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1302]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1303]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1304]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1305]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1306]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1307]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1308]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1309]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[130]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1310]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1311]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1312]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1313]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1314]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1315]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1316]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1317]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1318]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1319]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[131]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1320]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1321]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1322]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1323]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1324]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1325]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1326]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1327]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1328]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1329]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[132]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1330]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1331]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1332]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1333]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1334]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1335]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1336]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1337]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1338]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1339]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[133]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1340]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1341]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1342]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1343]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1344]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[134]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[135]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[136]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[137]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[138]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[139]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[13]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[140]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[141]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[142]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[143]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[144]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[145]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[146]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[147]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[148]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[149]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[14]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[150]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[151]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[152]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[153]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[154]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[155]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[156]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[157]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[158]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[159]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[15]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[160]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[161]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[162]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[163]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[164]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[165]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[166]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[167]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[168]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[169]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[16]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[170]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[171]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[172]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[173]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[174]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[175]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[176]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[177]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[178]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[179]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[17]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[180]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[181]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[182]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[183]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[184]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[185]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[186]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[187]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[188]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[189]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[18]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[190]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[191]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[192]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[193]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[194]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[195]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[196]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[197]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[198]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[199]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[19]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[1]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[200]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[201]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[202]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[203]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[204]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[205]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[206]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[207]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[208]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[209]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[20]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[210]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[211]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[212]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[213]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[214]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[215]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[216]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[217]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[218]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[219]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[21]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[220]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[221]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[222]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[223]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[224]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[225]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[226]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[227]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[228]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[229]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[22]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[230]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[231]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[232]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[233]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[234]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[235]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[236]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[237]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[238]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[239]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[23]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[240]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[241]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[242]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[243]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[244]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[245]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[246]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[247]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[248]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[249]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[24]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[250]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[251]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[252]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[253]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[254]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[255]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[256]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[257]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[258]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[259]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[25]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[260]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[261]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[262]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[263]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[264]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[265]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[266]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[267]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[268]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[269]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[26]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[270]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[271]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[272]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[273]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[274]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[275]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[276]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[277]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[278]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[279]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[27]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[280]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[281]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[282]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[283]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[284]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[285]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[286]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[287]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[288]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[289]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[28]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[290]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[291]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[292]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[293]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[294]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[295]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[296]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[297]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[298]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[299]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[29]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[2]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[300]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[301]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[302]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[303]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[304]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[305]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[306]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[307]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[308]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[309]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[30]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[310]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[311]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[312]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[313]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[314]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[315]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[316]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[317]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[318]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[319]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[31]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[320]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[321]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[322]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[323]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[324]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[325]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[326]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[327]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[328]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[329]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[32]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[330]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[331]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[332]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[333]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[334]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[335]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[336]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[337]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[338]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[339]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[33]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[340]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[341]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[342]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[343]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[344]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[345]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[346]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[347]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[348]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[349]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[34]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[350]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[351]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[352]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[353]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[354]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[355]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[356]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[357]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[358]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[359]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[35]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[360]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[361]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[362]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[363]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[364]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[365]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[366]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[367]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[368]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[369]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[36]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[370]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[371]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[372]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[373]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[374]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[375]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[376]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[377]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[378]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[379]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[37]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[380]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[381]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[382]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[383]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[384]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[385]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[386]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[387]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[388]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[389]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[38]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[390]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[391]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[392]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[393]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[394]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[395]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[396]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[397]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 19 мини.stp[398]
In: Default Storey
PredefinedType: ELEMENT
